# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071RB ST STM32L071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L071xx
  ICCARM.CCIncludePath2: ..\base-stm32l071-lib\CMSIS\Device\ST\STM32L0xx\Include; ..\base-stm32l071-lib\inc; ..\morse-lib\inc; inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: main.srec
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\base-lib\CMSIS\Device\ST\STM32L0xx\Include; ..\base-lib\inc; ..\morse-lib\inc; inc
  group (top)
    ../BASE-STM32L071-LIB/Release/Exe/: base-lib.a
    src/: main.c startup_stm32l071xx.s
    ../morse-lib/Release/Exe/: morse-lib.a
